# Keil uVision project led16.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408S STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: led16 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ./
  group Source Group 1
    ./: main.c
